options:
  parameters:
    author: Ram
    generate_options: qt_gui
    id: sineWaveFlowgraph
    output_language: python
    title: FM Radio
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: frequency
    outputmsgname: value
    showports: 'False'
    start: '72000000'
    step: '10000'
    stop: '74500000'
    value: '72000000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '2'
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: float
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '30000'
    decim: '2'
    gain: '1'
    samp_rate: samp_rate/2
    type: fir_filter_fff
    width: '3000'
    win: window.WIN_RECTANGULAR
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20000'
    decim: '5'
    gain: '1'
    samp_rate: samp_rate/4
    type: fir_filter_fff
    width: '3000'
    win: window.WIN_RECTANGULAR
  states: {}
- name: low_pass_filter_0_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '10000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/20
    type: fir_filter_fff
    width: '3000'
    win: window.WIN_RECTANGULAR
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '120000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '5000'
    win: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: '1000000'
    fc: tuning
    fftsize: '1024'
    rate: '1000'
    showrf: 'True'
    type: float
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: '1000000'
    fc: tuning
    fftsize: '1024'
    rate: '1000'
    showrf: 'True'
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: tuning
    dev_args: rtl=0
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0_0, '0', low_pass_filter_0_0_0, '0']
- [low_pass_filter_0_0_0, '0', low_pass_filter_0_0_0_0_0, '0']
- [low_pass_filter_0_0_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0_0_0_0_0, '0', qtgui_sink_x_0_0, '0']
- [low_pass_filter_0_1, '0', analog_wfm_rcv_0, '0']
- [soapy_rtlsdr_source_0, '0', low_pass_filter_0_1, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_sink_x_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
